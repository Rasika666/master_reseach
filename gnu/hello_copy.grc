options:
  parameters:
    gen_cmake: 'Off'
    generate_options: qt_gui
    id: sinewafe
    output_language: python
    title: hello
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '78'
    step: '1'
    stop: '1610'
    value: '387'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '2'
    stop: '30'
    value: '16'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: sr
  id: variable_qtgui_range
  parameters:
    start: 1e6
    step: '1'
    stop: 20e6
    value: 20e6
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: freq*1e6
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: sr
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.1'
    bw: sr
    fc: freq
    fftsize: '1024'
    grid: 'True'
    norm_window: 'True'
    type: complex
    ymin: '-1'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: sr
    fc: freq
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
